# Keil uVision project LabTemplate.uvprojx, settings and files
target Lab 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab1
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ./;..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Lab1.c
    ../inc/: PLL.c ST7735.c startup.s
